# Keil uVision project CANopen.uvprojx, settings and files
target CANpen (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CANopen +hex
  AfterMake: fromelf --bin --output=..\CANopen.bin ..\obj\CANopen.axf
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\CANopen\inc;..\CANopen\inc\stm32;..\CANopen\dictionary;..\CANopen\hardware;..\MasterSlaverPWM\PWMTimer;..\MasterSlaverPWM\softtimer;..\HARDWARE\PROTOCOL;..\HARDWARE\GPIO;..\MasterSlaverPWM\stepperMotor_Contral;..\HARDWARE\LobotSerialServo;..\HARDWARE\uart;..\HARDWARE\internalFlash;..\SYSTEM\error;..\HARDWARE\sensor
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c Control.c
  group HARDWARE
    ../HARDWARE/PROTOCOL/: protocol.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/internalFlash/: bsp_internalFlash.c
    ../HARDWARE/sensor/: sensor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/error/: error.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_flash.c
  group README
    ../: readme.txt
  group CANopen
    ../CANopen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CANopen_Driver
    ../CANopen/dictionary/: Master.c
    ../CANopen/hardware/: CanopenCan.c CanopenTimer.c CanopenContral.c
  group MasterSlaverPWM
    ../MasterSlaverPWM/PWMTimer/: PWMTimer.c
    ../MasterSlaverPWM/softtimer/: softtimer.c
    ../MasterSlaverPWM/stepperMotor_Contral/: motorContral.c
  group LobotSerialServo
    ../HARDWARE/LobotSerialServo/: LobotSerialServo.c
